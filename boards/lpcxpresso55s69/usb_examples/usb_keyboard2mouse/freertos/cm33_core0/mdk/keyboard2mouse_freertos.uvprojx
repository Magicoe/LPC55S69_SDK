# Keil uVision project keyboard2mouse_freertos.uvprojx, settings and files
target keyboard2mouse_freertos debug (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: IRAM(0x20000000,0x00044000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x000A0000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: keyboard2mouse_freertos.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _DEBUG=1, DEBUG, CPU_LPC55S69JBD100_cm33_core0=1, ARM_MATH_CM33, USB_STACK_FREERTOS, USB_STACK_FREERTOS_HEAP_SIZE=16384, USB_STACK_USE_DEDICATED_RAM=1, FSL_RTOS_FREE_RTOS
  c misc: --target=arm-arm-none-eabi  -Wall  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -fno-rtti  -fno-exceptions  -Wno-pedantic  -Wno-padded  -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default  -Wno-conversion  -Wno-switch-enum  -Wno-sign-compare  -Wno-sign-conversion  -Wno-cast-qual  -Wno-cast-align  -Wno-implicit-function-declaration  -Wno-strict-prototypes  -Wno-missing-variable-declarations  -Wno-self-assign  -Wno-missing-noreturn  -Wno-missing-field-initializers  -Wno-conditional-uninitialized  -Wno-tautological-constant-out-of-range-compare  -Wno-shadow  -Wno-missing-braces  -Wno-undef  -Wno-null-dereference  -Wno-bad-function-cast  -Wno-tautological-pointer-compare  -Wno-unknown-attributes  -Wno-unreachable-code  -Wno-unreachable-code-return  -Wno-ignored-attributes  -Wno-float-equal  -Wno-implicit-int  -Wno-format-nonliteral  -Wno-comma  -Wno-date-time  -Wno-unused-variable  -Wno-double-promotion  -Wno-logical-not-parentheses  -Wno-sometimes-uninitialized  -Wno-c++98-compat-pedantic  -Wno-zero-as-null-pointer-constant  -Wno-extra-semi  -Wno-old-style-cast  -Wno-weak-vtables  -Wno-implicit-exception-spec-mismatch
  c include: ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/GCC/ARM_CM33F;../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM33F;..;../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../../../../../platform/drivers;../../../../../../../platform/drivers/common;../../../../..;../../../../../../../middleware/usb;../../../../../../../middleware/usb/osa;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/device;../../../../../../../middleware/usb/host;../../../../../../../rtos/amazon-freertos/lib/include;../../../../../../../rtos/amazon-freertos/lib/include/private;../../../../../../../middleware/usb/host;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/osa;../../../../../../../middleware/usb/host;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/osa;../../../../../../../middleware/usb/device;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/osa;../../../../../../../middleware/usb/host;../../../../../../../middleware/usb/host/class;../../../../../../../middleware/usb/host/class;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../middleware/usb/phy;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/serial_manager;../../../../../../../components/lists
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: ../..;..;../../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x100" 
--predefine="-D__usb_use_usbram__=1"
  group doc
    ../: readme.txt
  group source
    ../: app.h app.c host_keyboard.c host_keyboard.h usb_host_config.h device_mouse.c device_mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h FreeRTOSConfig.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb-host
    ../../../../../../../middleware/usb/host/: usb_host_ip3516hs.c usb_host_ip3516hs.h usb_host_ohci.c usb_host_ohci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb-include
    ../../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c usb_osa.h usb_osa_freertos.h usb_osa_freertos.c usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group usb-device-source-lpcip3511
    ../../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb-device-include
    ../../../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group amazon-freertos-FreeRTOS-portable
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/GCC/ARM_CM33F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
  group amazon-freertos-license
    ../../../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group usb-host-class
    ../../../../../../../middleware/usb/host/class/: usb_host_hid.c usb_host_hid.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-hid
    ../: usb_device_hid.c usb_device_hid.h
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_iocon.h fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c
  group device
    ../../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group usb-phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group component/uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target keyboard2mouse_freertos release (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: as above
  output: keyboard2mouse_freertos.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _DEBUG=0, NDEBUG, CPU_LPC55S69JBD100_cm33_core0=1, ARM_MATH_CM33, USB_STACK_FREERTOS, USB_STACK_FREERTOS_HEAP_SIZE=16384, USB_STACK_USE_DEDICATED_RAM=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: ../..;..;../../../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above

# Keil uVision project mbedtls_benchmark.uvprojx, settings and files
target mbedtls_benchmark debug (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: IRAM(0x20000000,0x00044000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x000A0000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: mbedtls_benchmark.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, FREESCALE_KSDK_BM, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"'
  c misc: --target=arm-arm-none-eabi  -Wall  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -fno-rtti  -fno-exceptions  -Wno-pedantic  -Wno-padded  -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default  -Wno-conversion  -Wno-switch-enum  -Wno-sign-compare  -Wno-sign-conversion  -Wno-cast-qual  -Wno-cast-align  -Wno-implicit-function-declaration  -Wno-strict-prototypes  -Wno-missing-variable-declarations  -Wno-self-assign  -Wno-missing-noreturn  -Wno-missing-field-initializers  -Wno-conditional-uninitialized  -Wno-tautological-constant-out-of-range-compare  -Wno-shadow  -Wno-missing-braces  -Wno-undef  -Wno-null-dereference  -Wno-bad-function-cast  -Wno-tautological-pointer-compare  -Wno-unknown-attributes  -Wno-unreachable-code  -Wno-unreachable-code-return  -Wno-ignored-attributes  -Wno-float-equal  -Wno-implicit-int  -Wno-format-nonliteral  -Wno-comma  -Wno-date-time  -Wno-unused-variable  -Wno-double-promotion  -Wno-logical-not-parentheses  -Wno-sometimes-uninitialized  -Wno-c++98-compat-pedantic  -Wno-zero-as-null-pointer-constant  -Wno-extra-semi  -Wno-old-style-cast  -Wno-weak-vtables  -Wno-implicit-exception-spec-mismatch
  c include: ..;../..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC55S69;../../../../../../middleware/mbedtls/include;../../../../../../middleware/mbedtls/port/ksdk;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/utilities/str;../../../../../../devices/LPC55S69/utilities;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/LPC55S69/drivers
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../devices/LPC55S69/arm/keil_lib_power.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x8000"
  group source
    ../: benchmark.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_casper.h fsl_casper.c fsl_hashcrypt.h fsl_hashcrypt.c fsl_rng.h fsl_iocon.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group mbedTLS-mbedTLS_include
    ../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedTLS-mbedTLS_source
    ../../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c pkcs11.c
  group mbedTLS-mbedTLS_port
    ../../../../../../middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group device
    ../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target mbedtls_benchmark release (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: as above
  output: mbedtls_benchmark.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, PRINTF_ADVANCED_ENABLE=1, PRINTF_FLOAT_ENABLE=1, FREESCALE_KSDK_BM, MBEDTLS_CONFIG_FILE='\"ksdk_mbedtls_config.h\"'
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above

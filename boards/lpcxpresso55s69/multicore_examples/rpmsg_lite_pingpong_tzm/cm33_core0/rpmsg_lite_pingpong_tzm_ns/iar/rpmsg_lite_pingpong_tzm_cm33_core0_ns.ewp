# IAR project rpmsg_lite_pingpong_tzm_cm33_core0_ns.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33; MULTICORE_APP=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../rpmsg_lite_pingpong_tzm_ns; ../../..; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/LPC55S69; ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../../middleware/multicore/mcmgr/src; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../devices/LPC55S69/utilities/str; ../../../../../../../devices/LPC55S69/utilities; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/LPC55S69/drivers; ../../../../../../../middleware/multicore/rpmsg_lite/lib/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: rpmsg_lite_pingpong_tzm_cm33_core0_ns.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000; __use_shmem__=1
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../devices/LPC55S69/iar/iar_lib_power.a; ../../rpmsg_lite_pingpong_tzm_s/iar/debug/rpmsg_lite_pingpong_tzm_cm33_core0_s_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33; MULTICORE_APP=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkAdditionalLibs: ../../../../../../../devices/LPC55S69/iar/iar_lib_power.a; ../../rpmsg_lite_pingpong_tzm_s/iar/release/rpmsg_lite_pingpong_tzm_cm33_core0_s_import_lib.o
  group source
    ../: main_master_tzm_ns.c rpmsg_config.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group trustzone
    ../: veneer_table.h
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_lpc55s69.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group rpmsg_lite
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/porting
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69/: rpmsg_platform.h
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/lpc55s69/: rpmsg_platform.c
  group rpmsg_lite/env/bm
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_bm.c
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_env.h
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_iocon.h fsl_mailbox.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_power.h fsl_power.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group device
    ../../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0_ns.c system_LPC55S69_cm33_core0_ns.h
  group startup
    ../../../../../../../devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0_ns.s
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h

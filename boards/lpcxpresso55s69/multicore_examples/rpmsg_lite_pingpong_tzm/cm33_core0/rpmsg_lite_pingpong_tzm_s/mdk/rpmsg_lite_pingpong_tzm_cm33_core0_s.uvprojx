# Keil uVision project rpmsg_lite_pingpong_tzm_cm33_core0_s.uvprojx, settings and files
target rpmsg_lite_pingpong_tzm_cm33_core0_s debug (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: IRAM(0x20000000,0x00044000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x000A0000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: rpmsg_lite_pingpong_tzm_cm33_core0_s.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, MULTICORE_APP=1
  c misc: --target=arm-arm-none-eabi  -Wall  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -fno-rtti  -fno-exceptions  -Wno-pedantic  -Wno-padded  -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default  -Wno-conversion  -Wno-switch-enum  -Wno-sign-compare  -Wno-sign-conversion  -Wno-cast-qual  -Wno-cast-align  -Wno-implicit-function-declaration  -Wno-strict-prototypes  -Wno-missing-variable-declarations  -Wno-self-assign  -Wno-missing-noreturn  -Wno-missing-field-initializers  -Wno-conditional-uninitialized  -Wno-tautological-constant-out-of-range-compare  -Wno-shadow  -Wno-missing-braces  -Wno-undef  -Wno-null-dereference  -Wno-bad-function-cast  -Wno-tautological-pointer-compare  -Wno-unknown-attributes  -Wno-unreachable-code  -Wno-unreachable-code-return  -Wno-ignored-attributes  -Wno-float-equal  -Wno-implicit-int  -Wno-format-nonliteral  -Wno-comma  -Wno-date-time  -Wno-unused-variable  -Wno-double-promotion  -Wno-logical-not-parentheses  -Wno-sometimes-uninitialized  -Wno-c++98-compat-pedantic  -Wno-zero-as-null-pointer-constant  -Wno-extra-semi  -Wno-old-style-cast  -Wno-weak-vtables  -Wno-implicit-exception-spec-mismatch
  c include: ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69;..;../../../rpmsg_lite_pingpong_tzm_s;../../..;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC55S69;../../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../middleware/multicore/rpmsg_lite/lib/include;../../../../../../../middleware/multicore/mcmgr/src;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/drivers;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../devices/LPC55S69/utilities;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../devices/LPC55S69/drivers;../../../../../../../middleware/multicore/rpmsg_lite/lib/include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: ../../../cm33_core1/mdk/debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash_s.scf
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power.lib 
--remove 
--import-cmse-lib-out="./debug/rpmsg_lite_pingpong_tzm_s_CMSE_Lib.o" 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__use_shmem__=1"
  group source
    ../: main_master_tzm_s.c rpmsg_config.h
    ./: incbin.S
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group trustzone
    ../: tzm_config.c tzm_config.h veneer_table.h veneer_table.c
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_lpc55s69.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group rpmsg_lite-porting
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69/: rpmsg_platform.h
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/lpc55s69/: rpmsg_platform.c
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_iocon.h fsl_mailbox.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_power.h fsl_power.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group device
    ../../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0_s.c system_LPC55S69_cm33_core0_s.h
  group startup
    ../../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0_s.s
  group rpmsg_lite-env-bm
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_bm.c
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_env.h
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
  group rpmsg_lite
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
target rpmsg_lite_pingpong_tzm_cm33_core0_s release (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: as above
  output: rpmsg_lite_pingpong_tzm_cm33_core0_s.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, MULTICORE_APP=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: ../../../cm33_core1/mdk/release
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash_s.scf
  link misc: ../../../../../../../devices/LPC55S69/arm/keil_lib_power.lib 
--remove 
--import-cmse-lib-out="./release/rpmsg_lite_pingpong_tzm_s_CMSE_Lib.o" 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__use_shmem__=1"

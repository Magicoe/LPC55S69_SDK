# IAR project erpc_matrix_multiply_rpmsg_rtos_cm33_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33; MULTICORE_APP=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM33F; ..; ../..; ../../service; ../../../..; ../../../erpc_common; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC55S69; ../../../../../../rtos/amazon-freertos/lib/include; ../../../../../../rtos/amazon-freertos/lib/include/private; ../../../../freertos_config_board/cm33_core0; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69; ../../../../../../devices/LPC55S69/drivers; ../../../../../../devices/LPC55S69/drivers; ../../../../../../devices/LPC55S69/drivers; ../../../../../../devices/LPC55S69/drivers; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../devices/LPC55S69/drivers; ../../../../../../devices/LPC55S69/drivers; ../../../../../../devices/LPC55S69; ../../../../../../devices/LPC55S69/drivers; ../../../../../../devices/LPC55S69/drivers; ../../../../../../devices/LPC55S69/utilities/str; ../../../../../../devices/LPC55S69/utilities; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/LPC55S69/drivers; ../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../devices/LPC55S69/utilities; ../../../../../../middleware/multicore/erpc/erpc_c/infra; ../../../../../../middleware/multicore/erpc/erpc_c/port; ../../../../../../middleware/multicore/erpc/erpc_c/setup; ../../../../../../middleware/multicore/erpc/erpc_c/transports; ../../../../../../middleware/multicore/erpc/erpc_c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../../..; ../../../../freertos_config_board/cm33_core0
  ILINK.IlinkOutputFile: erpc_matrix_multiply_rpmsg_rtos_cm33_core0.out
  ILINK.IlinkKeepSymbols: _erpc_matrix_multiply_rpmsg_rtos_cm33_core1_image
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000; __use_shmem__=1
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC55S69/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33; MULTICORE_APP=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: main_core0.c FreeRTOSConfig.h
    ../../: rpmsg_config.h erpc_config.h
  group erpc
    ../../../erpc_common/: erpc_error_handler.h erpc_error_handler.cpp
  group erpc/infra
    ../../../../../../middleware/multicore/erpc/erpc_c/infra/: erpc_client_manager.h erpc_client_manager.cpp erpc_version.h erpc_codec.h erpc_basic_codec.h erpc_transport.h erpc_message_buffer.h erpc_message_loggers.h erpc_common.h erpc_manually_constructed.h erpc_crc16.h erpc_basic_codec.cpp erpc_message_buffer.cpp erpc_message_loggers.cpp erpc_crc16.cpp
  group erpc/setup
    ../../../../../../middleware/multicore/erpc/erpc_c/setup/: erpc_client_setup.h erpc_client_setup.cpp erpc_setup_rpmsg_lite_rtos_master.cpp erpc_setup_mbf_rpmsg.cpp erpc_transport_setup.h erpc_mbf_setup.h
  group erpc/transports
    ../../../../../../middleware/multicore/erpc/erpc_c/transports/: erpc_rpmsg_lite_base_transport.h erpc_rpmsg_lite_rtos_transport.h erpc_rpmsg_lite_rtos_transport.cpp
  group erpc/port
    ../../../../../../middleware/multicore/erpc/erpc_c/port/: erpc_port.h erpc_port_freertos.cpp erpc_config_internal.h
  group service
    ../../service/: erpc_matrix_multiply.erpc erpc_matrix_multiply.h erpc_matrix_multiply_client.cpp
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_lpc55s69.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/porting
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/lpc55s69/: rpmsg_platform.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/lpc55s69/: rpmsg_platform.c
  group rpmsg_lite/env/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_env.h rpmsg_queue.h
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_mailbox.h fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_power.h fsl_power.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_reset.h fsl_reset.c
  group amazon-freertos/license
    ../../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos/include
    ../../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos/FreeRTOS
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM33F/: fsl_tickless_systick.c fsl_tickless_generic.h portasm.s port.c portmacro.h
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_3.c
  group device
    ../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h

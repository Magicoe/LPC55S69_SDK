# Keil uVision project ntag_i2c_explorer_blink.uvprojx, settings and files
target ntag_i2c_explorer_blink debug (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: IRAM(0x20000000,0x00044000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x000A0000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: ntag_i2c_explorer_blink.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, PRINTF_ADVANCED_ENABLE=1, I2C_LPC, HAVE_STDBOOL_H, HAVE_STDINT_H
  c misc: --target=arm-arm-none-eabi  -Wall  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -fno-rtti  -fno-exceptions  -Wno-pedantic  -Wno-padded  -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default  -Wno-conversion  -Wno-switch-enum  -Wno-sign-compare  -Wno-sign-conversion  -Wno-cast-qual  -Wno-cast-align  -Wno-implicit-function-declaration  -Wno-strict-prototypes  -Wno-missing-variable-declarations  -Wno-self-assign  -Wno-missing-noreturn  -Wno-missing-field-initializers  -Wno-conditional-uninitialized  -Wno-tautological-constant-out-of-range-compare  -Wno-shadow  -Wno-missing-braces  -Wno-undef  -Wno-null-dereference  -Wno-bad-function-cast  -Wno-tautological-pointer-compare  -Wno-unknown-attributes  -Wno-unreachable-code  -Wno-unreachable-code-return  -Wno-ignored-attributes  -Wno-float-equal  -Wno-implicit-int  -Wno-format-nonliteral  -Wno-comma  -Wno-date-time  -Wno-unused-variable  -Wno-double-promotion  -Wno-logical-not-parentheses  -Wno-sometimes-uninitialized  -Wno-c++98-compat-pedantic  -Wno-zero-as-null-pointer-constant  -Wno-extra-semi  -Wno-old-style-cast  -Wno-weak-vtables  -Wno-implicit-exception-spec-mismatch
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC55S69;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../middleware/ntag_i2c_plus/inc;../../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc;../../../../../../middleware/ntag_i2c_plus/HAL_ISR;../../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc;../../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc;../../../../../../middleware/ntag_i2c_plus/HAL_NTAG;../../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/utilities/str;../../../../../../devices/LPC55S69/utilities;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../devices/LPC55S69/drivers
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../devices/LPC55S69/arm/keil_lib_power.lib 
--remove
  group source
    ../: ntag_i2c_explorer_blink.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_pint.h fsl_pint.c fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group ntag_i2c_plus-HAL_NTAG
    ../../../../../../middleware/ntag_i2c_plus/HAL_NTAG/inc/: ntag_bridge.h ntag_defines.h ntag_device_list.h ntag_driver.h
    ../../../../../../middleware/ntag_i2c_plus/HAL_NTAG/: ntag_driver_intern.h ntag_bridge.c ntag_driver.c
  group ntag_i2c_plus-HAL_I2C
    ../../../../../../middleware/ntag_i2c_plus/HAL_I2C/inc/: HAL_I2C_driver.h HAL_I2C_lpc_fsl.h
    ../../../../../../middleware/ntag_i2c_plus/HAL_I2C/: i2c_lpc_fsl.c
  group ntag_i2c_plus-HAL_ISR
    ../../../../../../middleware/ntag_i2c_plus/HAL_ISR/inc/: HAL_ISR_callback_list.h HAL_ISR_driver.h
    ../../../../../../middleware/ntag_i2c_plus/HAL_ISR/: isr_driver_intern.h isr_lpc_intern.h isr_common.c isr_lpc.c
  group ntag_i2c_plus-HAL_TMR
    ../../../../../../middleware/ntag_i2c_plus/HAL_TMR/inc/: HAL_timer_driver.h
    ../../../../../../middleware/ntag_i2c_plus/HAL_TMR/: timer_driver.c
  group ntag_i2c_plus-ntag_i2c_plus_include
    ../../../../../../middleware/ntag_i2c_plus/inc/: global_types.h nfc_device.h
  group device
    ../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target ntag_i2c_explorer_blink release (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: as above
  output: ntag_i2c_explorer_blink.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, PRINTF_ADVANCED_ENABLE=1, I2C_LPC, HAVE_STDBOOL_H, HAVE_STDINT_H
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above

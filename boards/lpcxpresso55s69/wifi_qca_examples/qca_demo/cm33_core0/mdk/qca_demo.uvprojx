# Keil uVision project qca_demo.uvprojx, settings and files
target qca_demo debug (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: IRAM(0x20000000,0x00044000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x000A0000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: qca_demo.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS
  c misc: --target=arm-arm-none-eabi  -Wall  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -fno-rtti  -fno-exceptions  -Wno-pedantic  -Wno-padded  -Wno-unused-parameter  -Wno-missing-prototypes  -Wno-covered-switch-default  -Wno-conversion  -Wno-switch-enum  -Wno-sign-compare  -Wno-sign-conversion  -Wno-cast-qual  -Wno-cast-align  -Wno-implicit-function-declaration  -Wno-strict-prototypes  -Wno-missing-variable-declarations  -Wno-self-assign  -Wno-missing-noreturn  -Wno-missing-field-initializers  -Wno-conditional-uninitialized  -Wno-tautological-constant-out-of-range-compare  -Wno-shadow  -Wno-missing-braces  -Wno-undef  -Wno-null-dereference  -Wno-bad-function-cast  -Wno-tautological-pointer-compare  -Wno-unknown-attributes  -Wno-unreachable-code  -Wno-unreachable-code-return  -Wno-ignored-attributes  -Wno-float-equal  -Wno-implicit-int  -Wno-format-nonliteral  -Wno-comma  -Wno-date-time  -Wno-unused-variable  -Wno-double-promotion  -Wno-logical-not-parentheses  -Wno-sometimes-uninitialized  -Wno-c++98-compat-pedantic  -Wno-zero-as-null-pointer-constant  -Wno-extra-semi  -Wno-old-style-cast  -Wno-weak-vtables  -Wno-implicit-exception-spec-mismatch
  c include: ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/GCC/ARM_CM33F;../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM33F;../../../../cm33_core0;../../../..;..;../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC55S69;../../../../../../rtos/amazon-freertos/lib/include;../../../../../../rtos/amazon-freertos/lib/include/private;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/gt202;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/silex2401;../../../../../../middleware/wifi_qca;../../../../../../middleware/wifi_qca/include;../../../../../../middleware/wifi_qca/include/AR6002;../../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw;../../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw;../../../../../../middleware/wifi_qca/custom_src/stack_custom;../../../../../../middleware/wifi_qca/custom_src/include;../../../../../../middleware/wifi_qca/common_src/include;../../../../../../middleware/wifi_qca/common_src/stack_common;../../../../../../middleware/wifi_qca/common_src/hcd;../../../../../../middleware/wifi_qca/common_src/wmi;../../../../../../middleware/wifi_qca/port;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/utilities/str;../../../../../../devices/LPC55S69/utilities;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos;../../../../../../middleware/wifi_qca/port/env/freertos;../../../../../../middleware/wifi_qca/port/drivers/flexcomm_freertos;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: ..;../../../..;../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: ../../../../../../devices/LPC55S69/arm/keil_lib_power.lib 
--remove
  group source
    ../: FreeRTOSConfig.h main.c wlan_qca400x.c wlan_qcom.c wlan_qcom.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group wifi_qca-port-shields-gt202
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/gt202/: wifi_shield_gt202.h
  group wifi_qca-port-shields-silex2401
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/silex2401/: wifi_shield_silex2401.h
  group amazon-freertos-FreeRTOS-portable
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/GCC/ARM_CM33F/: fsl_tickless_systick.c fsl_tickless_generic.h port.c portmacro.h
  group wifi_qca-common_src-wmi
    ../../../../../../middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group wifi_qca-common_src-stack_common
    ../../../../../../middleware/wifi_qca/common_src/storerecall/: dset_api.c
    ../../../../../../middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
  group wifi_qca-common_src-qapi
    ../../../../../../middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
    ../../../../../../middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group wifi_qca-common_src-include
    ../../../../../../middleware/wifi_qca/common_src/include/: dset_api.h driver_cxt.h a_drv_api.h wlan_api.h wmi_api.h hif_internal.h dset.h dbglog_api.h common_api.h bmi.h aggr_recv_api.h a_drv.h a_debug.h spi_hcd_if.h netbuf.h ieee80211.h htc_api.h
  group wifi_qca-common_src-htc
    ../../../../../../middleware/wifi_qca/common_src/htc/: htc.c
    ../../../../../../middleware/wifi_qca/common_src/hcd/: spi_hcd.c
  group wifi_qca-common_src-driver
    ../../../../../../middleware/wifi_qca/common_src/driver/: driver_main.c driver_txrx.c driver_netbuf.c driver_init.c driver_diag.c
  group wifi_qca-common_src-api_interface
    ../../../../../../middleware/wifi_qca/common_src/api_interface/: api_wmi_rx.c api_ioctl.c api_txrx.c api_init.c
  group wifi_qca-common_src-hw_interface
    ../../../../../../middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group wifi_qca-common_src-storerecall
    ../../../../../../middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group wifi_qca-common_src-hcd
    ../../../../../../middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group wifi_qca-common_src-bmi
    ../../../../../../middleware/wifi_qca/common_src/bmi/: bmi.c
  group wifi_qca-common_src-util
    ../../../../../../middleware/wifi_qca/common_src/util/: util.c
  group wifi_qca-common_src-reorder
    ../../../../../../middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group wifi_qca-custom_src-stack_custom
    ../../../../../../middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c qca_structs.h custom_stack_offload.h cust_api_stack_txrx.c
  group wifi_qca-custom_src-qapi
    ../../../../../../middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group wifi_qca-custom_src-include
    ../../../../../../middleware/wifi_qca/custom_src/include/: cust_netbuf.h a_osapi.h a_config.h wlan_config.h custom_wlan_api.h a_types.h
  group wifi_qca-custom_src-api_interface
    ../../../../../../middleware/wifi_qca/custom_src/api_interface/: cust_api_wmi_rx.c cust_api_ioctl.c cust_api_txrx.c cust_api_init.c
  group wifi_qca-custom_src-driver
    ../../../../../../middleware/wifi_qca/custom_src/driver/: cust_driver_netbuf.c cust_driver_main.c
  group wifi_qca-custom_src-hw_interface
    ../../../../../../middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group wifi_qca-include
    ../../../../../../middleware/wifi_qca/include/: wmi.h dbglog.h athdefs.h dbglog_id.h bmi_msg.h wlan_defs.h targaddrs.h pmu.h pkt_log.h p2p.h htc_services.h htc.h
    ../../../../../../middleware/wifi_qca/: qcom_api.h atheros_stack_offload.h atheros_wifi_internal.h atheros_wifi_api.h atheros_wifi.h
  group wifi_qca-include-AR6002-hw2.0-hw
    ../../../../../../middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_gpio_reg.h hw20_apb_map.h hw20_vmc_reg.h hw20_uart_reg.h hw20_si_reg.h hw20_rtc_reg.h hw20_mbox_reg.h hw20_mbox_host_reg.h
  group wifi_qca-include-AR6002
    ../../../../../../middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group wifi_qca-include-AR6002-hw4.0-hw
    ../../../../../../middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_wlan_reg.h hw40_rtc_reg.h
  group wifi_qca-port
    ../../../../../../middleware/wifi_qca/port/: wifi_common.h
  group amazon-freertos-license
    ../../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos-include
    ../../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos-FreeRTOS
    ../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group drivers
    ../../../../../../devices/LPC55S69/drivers/: fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_spi.c fsl_spi.h fsl_reset.h fsl_reset.c fsl_spi_dma.c fsl_spi_dma.h fsl_dma.c fsl_dma.h fsl_pint.h fsl_pint.c fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h
  group device
    ../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../devices/LPC55S69/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group wifi_qca-port-shields
    ../../../../../../middleware/wifi_qca/port/boards/lpcxpresso55s69/freertos/: wifi_shield.h wifi_shield.c
  group wifi_qca-port-env-freertos
    ../../../../../../middleware/wifi_qca/port/env/freertos/: wifi_port.h wifi_env_port.h wifi_env.c wifi_env.h
  group wifi_qca-port-drivers-flexcomm_freertos
    ../../../../../../middleware/wifi_qca/port/drivers/flexcomm_freertos/: wifi_spi.h wifi_spi.c
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
target qca_demo release (ARM-ADS)
  device: LPC55S69JBD100:M33_CORE0 NXP
  pack: Keil.LPC5500_DFP.0.0.2
  cpu: as above
  output: qca_demo.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, A_LITTLE_ENDIAN, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: ..;../../../..;../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above

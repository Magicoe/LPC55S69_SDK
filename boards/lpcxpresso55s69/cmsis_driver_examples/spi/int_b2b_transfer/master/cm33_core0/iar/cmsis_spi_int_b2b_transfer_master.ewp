# IAR project cmsis_spi_int_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../../CMSIS/Driver/Include; ../../../../../..; ../../../../../../../../CMSIS/Include; ../../../../../../../../devices; ../../../../../../../../devices/LPC55S69; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/cmsis_drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../devices/LPC55S69/utilities/str; ../../../../../../../../devices/LPC55S69/utilities; ../../../../../../../../components/uart; ../../../../../../../../components/serial_manager; ../../../../../../../../components/serial_manager; ../../../../../../../../components/lists; ../../../../../../../../devices/LPC55S69/drivers; ../../../../../../../../CMSIS/Driver/Include; ../../../../../../../../CMSIS/Driver/Include; ../../../../../../../../devices/LPC55S69/template
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_spi_int_b2b_transfer_master.out
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../devices/LPC55S69/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_spi_int_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../../../../../../../../devices/LPC55S69/template/: RTE_Device.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/LPC55S69/drivers/: fsl_dma.c fsl_dma.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_iocon.h fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
    ../../../../../../../../devices/LPC55S69/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c
  group device
    ../../../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group startup
    ../../../../../../../../devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0.s
  group utilities
    ../../../../../../../../devices/LPC55S69/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.c fsl_str.h
  group component/uart
    ../../../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../../../components/lists/: generic_list.h generic_list.c
  group CMSIS
    ../../../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
  group CMSIS_driver
    ../../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
  group src
    ../: RTE_Device.h
